# Keil uVision project GRAFT_COM.uvprojx, settings and files
target GRAFT_COM (ARM-ADS)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: GRAFT_COM +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;./1HARDWARE/BMI088;./1MATH/Quaternion;./1MATH/Math;./1HARDWARE/NRF24L01;./1MATH/Fliter;./1MATH/PID;./1Control;./1HARDWARE/MOTOR;./1ANTOTC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_spi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Hardware
    ./1HARDWARE/BMI088/: BMI08A.c BMI08G.c BMI088.c
    ./1HARDWARE/NRF24L01/: nrf24l01.c
    ./1HARDWARE/MOTOR/: ESC.c
  group ParamInit
    ./1HARDWARE/BMI088/: Param&init.c
    ./1Param&init/Flash/: flash.c
  group Math
    ./1MATH/Quaternion/: imu.c
    ./1MATH/Math/: myMath.c
    ./1MATH/Fliter/: filter.c kalman.c
    ./1MATH/PID/: pid.c
  group Control
    ./1Control/: control.c
  group ANTOTC
    ./1ANTOTC/: ANTOTC.c
software components: CMSIS:CORE 4.3.0
